<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzn2l_coremark_fsp200_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>
