# IAR project Backup of rzn2l_coremark_fsp200_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  prebuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --generate --compiler IAR --devicefamily rzn "configuration.xml" 2> "%TEMP%\rasc_stderr.out""
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily rzn "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
