<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RZN2L_RSK_OpENer_single.ewp</path>
    </project>
    <batchBuild/>
</workspace>
