<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\start_ra2l1_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>
